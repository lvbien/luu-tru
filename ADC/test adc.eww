<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\DMA\dma.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\PWM\pwm.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TEST.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\TIMER\timer.ewp</path>
    </project>
    <batchBuild />
</workspace>
